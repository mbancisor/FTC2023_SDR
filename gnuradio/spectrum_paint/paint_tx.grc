options:
  parameters:
    category: Custom
    generate_options: qt_gui
    id: paint_tx
    output_language: python
  states: {}

blocks:
- name: freq_lo
  id: variable
  parameters:
    value: '1000000000'
  states: {}
- name: frequency
  id: variable
  parameters:
    value: '915000000'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '2000000'
  states: {}
- name: samp_rate_0
  id: variable
  parameters:
    value: '1000000'
  states: {}
- name: tx_gain
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '0.25'
    stop: '89'
    value: '70'
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: marcy.bin
    repeat: 'True'
    type: byte
  states: {state: disabled}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: '4096'
    type: complex
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: blocks_vector_to_stream_0
  id: blocks_vector_to_stream
  parameters:
    num_items: '4096'
    type: complex
  states: {}
- name: digital_ofdm_cyclic_prefixer_0
  id: digital_ofdm_cyclic_prefixer
  parameters:
    cp_len: '192'
    input_size: '4096'
    tagname: ''
  states: {}
- name: fft_vxx_0
  id: fft_vxx
  parameters:
    fft_size: '4096'
    forward: 'True'
    shift: 'True'
    type: complex
    window: window.rectangular(4096)
  states: {}
- name: fosphor_glfw_sink_c_0_0
  id: fosphor_glfw_sink_c
  parameters:
    freq_center: freq_lo
    freq_span: samp_rate
  states: {}
- name: iio_pluto_sink_0
  id: iio_pluto_sink
  parameters:
    attenuation1: '10'
    bandwidth: '4800000'
    buffer_size: '32768'
    cyclic: 'False'
    filter_source: '''Auto'''
    frequency: freq_lo
    samplerate: samp_rate
    type: fc32
    uri: 192.168.2.1
  states: {}
- name: iio_pluto_source_0
  id: iio_pluto_source
  parameters:
    bandwidth: '4800000'
    bbdc: 'True'
    buffer_size: 32768*4
    filter_source: '''Auto'''
    frequency: freq_lo
    gain1: '''manual'''
    manual_gain1: '30'
    quadrature: 'True'
    rfdc: 'True'
    samplerate: samp_rate
    type: fc32
    uri: 192.168.2.1
  states: {}
- name: paint_image_source_0
  id: paint_image_source
  parameters:
    autocontrast: '1'
    bt709_map: '1'
    image_file: /home/ubuntu/Desktop/Final_files_v7/gnuradio/spectrum_paint/gnuradio_logo_glyphs_as_paths.png
    image_flip: '1'
    image_invert: '0'
    repeatmode: '1'
  states: {}
- name: paint_paint_bc_0
  id: paint_paint_bc
  parameters:
    equalization: EQUALIZATION_OFF
    randomsrc: INTERNAL
    repeats: '4'
    width: '288'
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    size: '4096'
    type: complex
    xmax: '15'
    xmin: '-15'
    ymax: '15'
    ymin: '-15'
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '4096'
    int_max: '-51'
    int_min: '-77'
    showports: 'True'
    type: complex
    wintype: window.WIN_RECTANGULAR
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: paint-cyclic
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: paint-cyclic
  states: {}

connections:
- [blocks_file_source_0, '0', paint_paint_bc_0, '0']
- [blocks_stream_to_vector_0, '0', fft_vxx_0, '0']
- [blocks_stream_to_vector_0, '0', virtual_sink_0, '0']
- [blocks_throttle_0, '0', iio_pluto_sink_0, '0']
- [blocks_vector_to_stream_0, '0', qtgui_const_sink_x_0, '0']
- [digital_ofdm_cyclic_prefixer_0, '0', blocks_throttle_0, '0']
- [fft_vxx_0, '0', blocks_vector_to_stream_0, '0']
- [iio_pluto_source_0, '0', fosphor_glfw_sink_c_0_0, '0']
- [paint_image_source_0, '0', paint_paint_bc_0, '0']
- [paint_paint_bc_0, '0', blocks_stream_to_vector_0, '0']
- [paint_paint_bc_0, '0', qtgui_waterfall_sink_x_0, '0']
- [virtual_source_0, '0', digital_ofdm_cyclic_prefixer_0, '0']

metadata:
  file_format: 1
