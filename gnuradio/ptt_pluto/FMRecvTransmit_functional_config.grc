options:
  parameters:
    generate_options: qt_gui
    id: FMRecvTransmit
    output_language: python
    title: FMRecvTransmit
  states: {}

blocks:
- name: LO
  id: variable_qtgui_range
  parameters:
    label: LO Frequency
    start: '70000000'
    step: '1'
    stop: '6000000000'
    value: '467000000'
    widget: counter
  states: {}
- name: PTT
  id: variable_qtgui_chooser
  parameters:
    label: RF OUT
    label0: 'ON'
    label1: 'OFF'
    num_opts: '2'
    option0: '0'
    option1: '-89'
    type: int
    value: '-89'
    widget: radio_buttons
  states: {}
- name: audio_in_rate
  id: variable
  parameters:
    value: '16000'
  states: {}
- name: audio_out_rate
  id: variable
  parameters:
    value: '16000'
  states: {}
- name: quad_rate_rx
  id: variable
  parameters:
    value: '128000'
  states: {}
- name: quad_rate_tx
  id: variable
  parameters:
    value: '128000'
  states: {}
- name: sample_rate_rx
  id: variable
  parameters:
    value: '1152000'
  states: {}
- name: sample_rate_tx
  id: variable
  parameters:
    value: '512000'
  states: {}
- name: uri
  id: variable
  parameters:
    value: '"ip:192.168.2.1"'
  states: {}
- name: analog_nbfm_rx_0
  id: analog_nbfm_rx
  parameters:
    audio_rate: audio_out_rate
    max_dev: 5e3
    quad_rate: quad_rate_rx
    tau: '75e-6'
  states: {}
- name: analog_nbfm_tx_0
  id: analog_nbfm_tx
  parameters:
    audio_rate: audio_in_rate
    fh: '-1.0'
    max_dev: 5e3
    quad_rate: quad_rate_tx
    tau: '75e-6'
  states: {state: disabled}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: audio_out_rate
  states: {}
- name: blocks_add_const_vxx_0
  id: blocks_add_const_vxx
  parameters:
    const: '1'
    type: float
  states: {state: disabled}
- name: blocks_add_const_vxx_0_0
  id: blocks_add_const_vxx
  parameters:
    const: '1'
    type: float
  states: {state: disabled}
- name: blocks_complex_to_float_0
  id: blocks_complex_to_float
  parameters: {}
  states: {state: disabled}
- name: blocks_copy_1
  id: blocks_copy
  parameters:
    enabled: 'True'
    type: complex
  states: {}
- name: blocks_float_to_short_0
  id: blocks_float_to_short
  parameters:
    scale: '16384'
  states: {state: disabled}
- name: blocks_float_to_short_1
  id: blocks_float_to_short
  parameters:
    scale: '16384'
  states: {state: disabled}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '0.5'
    type: float
  states: {}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    file: /home/ubuntu/Desktop/FTC2023_SDR/gnuradio/ptt_pluto/TurkeyMarch16k.wav
    repeat: 'True'
  states: {state: disabled}
- name: dc_blocker_xx_0
  id: dc_blocker_xx
  parameters:
    length: '32'
    long_form: 'True'
    type: ff
  states: {}
- name: iio_attr_sink_0
  id: iio_attr_sink
  parameters:
    attr_type: '0'
    channel: voltage0
    device: ad9361-phy
    output: 'True'
    uri: ip:192.168.2.1
  states: {state: disabled}
- name: iio_attr_sink_0_0
  id: iio_attr_sink
  parameters:
    attr_type: '0'
    channel: altvoltage1
    device: ad9361-phy
    output: 'True'
    uri: ip:192.168.2.1
  states: {state: disabled}
- name: iio_attr_sink_0_0_0
  id: iio_attr_sink
  parameters:
    attr_type: '0'
    channel: voltage0
    device: ad9361-phy
    output: 'False'
    uri: ip:192.168.2.1
  states: {state: disabled}
- name: iio_attr_updater_0
  id: iio_attr_updater
  parameters:
    attr: hardwaregain
    interval: '1000'
    value: str(PTT)
  states: {state: disabled}
- name: iio_attr_updater_1
  id: iio_attr_updater
  parameters:
    attr: frequency
    interval: '1000'
    value: str(LO)
  states: {state: disabled}
- name: iio_attr_updater_1_0
  id: iio_attr_updater
  parameters:
    attr: sampling_frequency
    interval: '1000'
    value: str(sample_rate_tx)
  states: {state: disabled}
- name: iio_device_sink_0
  id: iio_device_sink
  parameters:
    buffer_size: '16384'
    channels: '["voltage0","voltage1"]'
    cyclic: 'False'
    device: '"cf-ad9361-dds-core-lpc"'
    device_phy: ad9361-phy
    interpolation: '1'
    params: '[]'
    uri: ip:192.168.2.1
  states: {state: disabled}
- name: iio_pluto_source_0
  id: iio_pluto_source
  parameters:
    bandwidth: '200000'
    bbdc: 'False'
    buffer_size: '32768'
    filter_source: '''Auto'''
    frequency: LO
    gain1: '''slow_attack'''
    quadrature: 'True'
    rfdc: 'True'
    samplerate: sample_rate_rx
    type: fc32
    uri: uri
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: '5000'
    decim: (int)(sample_rate_rx / (quad_rate_rx))
    gain: '1'
    samp_rate: 'sample_rate_rx '
    type: fir_filter_ccf
    width: '2000'
    win: window.WIN_HAMMING
  states: {}
- name: low_pass_filter_1
  id: low_pass_filter
  parameters:
    cutoff_freq: '5000'
    decim: '1'
    gain: '1'
    samp_rate: quad_rate_tx
    type: fir_filter_ccf
    width: '2000'
    win: window.WIN_HAMMING
  states: {state: disabled}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: '16000'
    fc: '0'
    fftsize: '1024'
    type: float
  states: {state: disabled}
- name: qtgui_sink_x_1
  id: qtgui_sink_x
  parameters:
    bw: sample_rate_rx
    fc: '0'
    fftsize: '1024'
    name: RF In
    type: complex
  states: {}
- name: qtgui_sink_x_2
  id: qtgui_sink_x
  parameters:
    bw: '576000'
    fc: '0'
    fftsize: '16384'
    gui_hint: 3,0,1,1
    name: RF Out
    type: complex
  states: {state: disabled}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    entags: 'False'
    name: Audio
    size: '1024'
    srate: audio_out_rate
    type: float
  states: {}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    nconnections: '2'
    size: '1024'
    srate: sample_rate_tx
    type: float
  states: {state: disabled}
- name: rational_resampler_xxx_1
  id: rational_resampler_xxx
  parameters:
    decim: '1'
    interp: int(sample_rate_tx/quad_rate_tx)
    taps: ''
    type: ccc
  states: {state: disabled}

connections:
- [analog_nbfm_rx_0, '0', dc_blocker_xx_0, '0']
- [analog_nbfm_tx_0, '0', low_pass_filter_1, '0']
- [blocks_add_const_vxx_0, '0', blocks_float_to_short_0, '0']
- [blocks_add_const_vxx_0_0, '0', blocks_float_to_short_1, '0']
- [blocks_complex_to_float_0, '0', blocks_add_const_vxx_0, '0']
- [blocks_complex_to_float_0, '0', qtgui_time_sink_x_1, '0']
- [blocks_complex_to_float_0, '1', blocks_add_const_vxx_0_0, '0']
- [blocks_complex_to_float_0, '1', qtgui_time_sink_x_1, '1']
- [blocks_copy_1, '0', low_pass_filter_0, '0']
- [blocks_float_to_short_0, '0', iio_device_sink_0, '0']
- [blocks_float_to_short_1, '0', iio_device_sink_0, '1']
- [blocks_multiply_const_vxx_0, '0', audio_sink_0, '0']
- [blocks_multiply_const_vxx_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_wavfile_source_0, '0', analog_nbfm_tx_0, '0']
- [blocks_wavfile_source_0, '0', qtgui_sink_x_0, '0']
- [dc_blocker_xx_0, '0', blocks_multiply_const_vxx_0, '0']
- [iio_attr_updater_0, out, iio_attr_sink_0, attr]
- [iio_attr_updater_1, out, iio_attr_sink_0_0, attr]
- [iio_attr_updater_1_0, out, iio_attr_sink_0_0_0, attr]
- [iio_pluto_source_0, '0', blocks_copy_1, '0']
- [low_pass_filter_0, '0', analog_nbfm_rx_0, '0']
- [low_pass_filter_0, '0', qtgui_sink_x_1, '0']
- [low_pass_filter_1, '0', rational_resampler_xxx_1, '0']
- [rational_resampler_xxx_1, '0', blocks_complex_to_float_0, '0']
- [rational_resampler_xxx_1, '0', qtgui_sink_x_2, '0']

metadata:
  file_format: 1
