options:
  parameters:
    generate_options: qt_gui
    id: fm_radio
    output_language: python
    title: fm_radio
  states: {}

blocks:
- name: LPF_decimation
  id: variable
  parameters:
    value: '5'
  states: {}
- name: lna_gain
  id: variable_qtgui_range
  parameters:
    outputmsgname: value
    rangeType: int
    showports: 'False'
    start: '-1'
    step: '1'
    stop: '73'
    value: '73'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '2400000'
  states: {}
- name: tune
  id: variable_qtgui_range
  parameters:
    outputmsgname: value
    rangeType: int
    showports: 'False'
    start: '88100000'
    step: '100000'
    stop: '107900000'
    value: '101000000'
  states: {}
- name: analog_wfm_rcv_0
  id: analog_wfm_rcv
  parameters:
    audio_decimation: int(samp_rate/LPF_decimation/48e3)
    quad_rate: samp_rate/LPF_decimation
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: '48000'
  states: {}
- name: iio_pluto_source_0
  id: iio_pluto_source
  parameters:
    bandwidth: '20000000'
    bbdc: 'True'
    buffer_size: '32768'
    filter_source: '''Auto'''
    frequency: tune
    gain1: '''manual'''
    manual_gain1: lna_gain
    quadrature: 'True'
    rfdc: 'True'
    samplerate: samp_rate
    type: fc32
    uri: 192.168.2.1
  states: {}
- name: low_pass_filter_1
  id: low_pass_filter
  parameters:
    cutoff_freq: 100e3
    decim: LPF_decimation
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: 50e3
    win: window.WIN_HAMMING
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: tune*1e6
    fftsize: 2**12
    label1: Unfiltered
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate/LPF_decimation
    fc: '0'
    fftsize: 2**12
    label1: Low Passed
    type: complex
    ymin: '-200'
  states: {}
- name: qtgui_freq_sink_x_1
  id: qtgui_freq_sink_x
  parameters:
    bw: 48e3
    fc: '0'
    fftsize: 2**12
    label1: Audio
    type: float
  states: {}
- name: qtgui_time_sink_x_2
  id: qtgui_time_sink_x
  parameters:
    label1: Audio
    size: '1024'
    srate: 48e3
    type: float
  states: {}
- name: qtgui_time_sink_x_2_0
  id: qtgui_time_sink_x
  parameters:
    label1: LowPass_real
    label2: LowPass_Im
    size: '1024'
    srate: samp_rate/5
    type: complex
  states: {}

connections:
- [analog_wfm_rcv_0, '0', audio_sink_0, '0']
- [analog_wfm_rcv_0, '0', qtgui_freq_sink_x_1, '0']
- [analog_wfm_rcv_0, '0', qtgui_time_sink_x_2, '0']
- [iio_pluto_source_0, '0', low_pass_filter_1, '0']
- [iio_pluto_source_0, '0', qtgui_freq_sink_x_0, '0']
- [low_pass_filter_1, '0', analog_wfm_rcv_0, '0']
- [low_pass_filter_1, '0', qtgui_freq_sink_x_0_0, '0']
- [low_pass_filter_1, '0', qtgui_time_sink_x_2_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.4.0
